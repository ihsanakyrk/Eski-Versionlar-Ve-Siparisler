# Repository ihsanakyrk/Eski-Versionlar-Ve-Siparisler (continued)

## KiCad design [03.2025]-Entronom/Movita_CM4_CT_Router_V1.0/Movita_CM4_CT_Router_V1.0-2025-03-26_113524/Movita_CM4_CT_Router_V1.0.kicad_pcb (continued)

Parts:
C1, C10, C46, C47, C48: 10uF; C_0603_1608Metric
C2: 33pF; C_0603_1608Metric; MPN CL10C330JB8NNNC
C5, C6, C49, C53, C54: 100nF; C_0603_1608Metric
C7: 150pF; C_0603_1608Metric
C8: 4.7uF/50V; C_0603_1608Metric
C9: 100uF; C_1206_3216Metric; MPN HGC1206R5107M100NSPJ
C50: 22pF; C_0603_1608Metric
C51, C52: 22uF; C_0603_1608Metric; MPN CL10A226MQ8NRNC
C55: 220uF; CP_Elec_6.3x5.4; Manufacturer_Part_Number RVT1C221M0605
D1: 2SS100L-W; 2SS100LW; MPN 2SS100L-W
D2, D6, D7: LED_WHITE; LED_0603_1608Metric; MPN 0603 翠绿色 LED
D4: SS34FA; MPN SS34FA
D5: SS14
IC1: BL9342; SOT-23-6; MPN BL9342
IC2: MP1584EN; MP1584N; MPN MP1584EN
IC3: SY8113B; Manufacturer_Part_Number SY8113B
J1: JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical; MPN JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
L1: CDRH74NP-100MC-B; CDRH74NP100MCB; MPN CDRH74NP-100MC-B
L2: LQM21PN2R2MC0D; L_0805_2012Metric; MPN LQM21PN2R2MC0D
L3: HA42-4R7MT; Inductor_0402_4.7uH; MPN HA42-4R7MT
P1: TYPE-C 6P(073)
Q2: MMBT2222ALT1G; MPN MMBT2222A
R1, R16, R64: 10K; R_0603_1608Metric
R2: 1K; R_0603_1608Metric; MPN 0603WAF1001T5E
R5, R18: 40.2K; R_0603_1608Metric
R6: 124K; R_0603_1608Metric
R7, R17: 100K; R_0603_1608Metric
R8: 2.2K; R_0603_1608Metric
R9, R10, R13, R14, R72, R73, R74, R75: 10mR; R_1206_3216Metric
R15: 200K; R_0603_1608Metric
R19: 210K; R_0603_1608Metric
R20, R21, R69: 4.7K; R_0603_1608Metric
R68: DNP; R_0603_1608Metric
R70: 232K; R_0603_1608Metric; MPN FRC0603F2323TS
R71: 51K; R_0603_1608Metric; MPN 0603WAF5102T5E
TP1: DNP; TestPoint_Pad_1.0x1.0mm

Connections:
/CM4/3V3_KAMERA: R74.2; also elsewhere on the board
/CM4/+CM4_5V: R14.2; also elsewhere on the board
/PCIE /+3.3V_PCIE: R73.2; also elsewhere on the board
/Power Unit/3.3V: C2.1, C10.2, L2.1, R6.2, R9.1, R21.1, TP1.1
/Power Unit/5V: C9.1, L1.2, R10.1, R13.1, R14.1, R19.2, R20.1
/Power Unit/HUB_5V: R13.2; also elsewhere on the board
/Power Unit/REG1_3V3: C50.2, C51.2, C52.2, C53.2, C54.2, C55.1, L3.2, R69.1, R70.1, R72.1, R73.1, R74.1, R75.1
/Power Unit/RTC_3V3: R75.2; also elsewhere on the board
/Power Unit/SY8113B_Reg: C46.2, C47.2, C48.2, IC3.5 (IN), R10.2, R68.1
/Power Unit/USB_HUB_3V3: R72.2; also elsewhere on the board
/RP2040/GPIO19: R64.1; also elsewhere on the board
/RP2040/GPIO20: R1.1, R2.1; also elsewhere on the board
/RP2040/GPIO22: IC2.2 (EN), R7.2, R8.1; also elsewhere on the board
/RP2040/MicroUSB_3.3V: R9.2; also elsewhere on the board
Earth: C1.1, C8.1, C9.2, C10.1, C46.1, C47.1, C48.1, C51.1, C52.1, C53.1, C54.1, C55.2, D2.1 (K), D4.2, D5.A, D6.1 (K), D7.1 (K), IC1.2 (GND), IC2.5 (GND), IC2.9 (EP), IC3.2 (GND), J1.1, P1.A12 (GND), P1.B12 (GND), P1.MP (SHIELD), Q2.2 (E), R1.2, R5.2, R8.2, R15.2, R17.2, R18.2, R71.2; also elsewhere on the board
unnamed: C7.1, R17.1
unnamed: D2.2 (A), R69.2
unnamed: D6.2 (A), R20.2
unnamed: D7.2 (A), R21.2
unnamed: C5.1, IC1.1 (BS)
unnamed: IC1.4 (EN), Q2.3 (C), R16.2
unnamed: C2.2, IC1.3 (FB), R5.1, R6.1
unnamed: C5.2, D5.C, IC1.6 (SW), L2.2
unnamed: C6.2, IC2.8 (BST)
unnamed: C7.2, IC2.3 (COMP)
unnamed: IC2.4 (FB), R18.1, R19.1
unnamed: IC2.6 (FREQ), R15.1
unnamed: C6.1, D4.1, IC2.1 (SW), L1.1
unnamed: C49.1, IC3.1 (BS)
unnamed: IC3.4 (EN), R64.2, R68.2
unnamed: C50.1, IC3.3 (FB), R70.2, R71.1
unnamed: C49.2, IC3.6 (LX), L3.1
unnamed: Q2.1 (B), R2.2
VIN: C1.2, C8.2, D1.1, IC1.5 (IN), IC2.7 (VIN), R7.1, R16.1; also elsewhere on the board
VRAW: D1.2, J1.2, P1.A9 (VBUS), P1.B9 (VBUS); also elsewhere on the board

Notes on the sheet:
5V_REG
RP2040_Reg_OUTPUT
RP2040_Reg LED
5V_Reg LED
3V3_Reg1 OUTPUT
3V3_REG1 ENABLE
VIN_DIODE
4.5V-18V
LED
VIN
3.3V_REG
3.3V输出应用图
3V3_REG1 OUTPUT
3V3 REG

Parts:
C41, C42: 0.01uF; C_0603_1608Metric
C44: 1000pF; C_0603_1608Metric
D12: LED Red; LED_0603_1608Metric; Part Description Red 620nm LED Indication - Discrete 2.2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
D13: LED Red; LED_0603_1608Metric; Part Description Green 572nm LED Indication - Discrete 2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
J10, J11: JST_1x15-1MP_P1.25mm_Vertical
J12: PinHeader_2x04_P2.00mm_Vertical_MALE; PinHeader_2x04_P2.00mm_Vertical; MPN PinHeader_2x04_P2.00mm_Vertical_MALE
J15: JST_1x8-1MP_P1.25mm_Vertical; JST_1x8_1MP_P1.25mm_Vertical
R4, R42: 75R; R_0603_1608Metric
R11, R12, R51, R54, R60: 0R; R_0603_1608Metric
R49, R50, R52, R53, R56: DNP; R_0603_1608Metric
R55, R61, R62: 0R; R_0603_1608Metric; Part Description Resistor 0R M2012 5%
R57, R65: 1K; R_0402_1005Metric; Part Description Resistor 1K M1005 1% 63mW
R58, R59: 2.2K 1%; R_0402_1005Metric; Part Description Resistor 2.2K M1005 1% 63mW
T1: H1102NL; MPN H1102NLT
U8: 74LVC1G07SE-7; SOT-353_SC-70-5; Part Description Buffer, Non-Inverting 1 Element 1 Bit p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
U9: DF40C-100DS-0.4V; MODULE_CM4102008; MPN DF40C-100DS-0.4V(51)

Connections:
/CM4/3V3_KAMERA: J12.1, J12.5, R51.1, R54.1; also elsewhere on the board
/CM4/+1.8v: R56.1, U9.88 (+1.8v_(Output)), U9.90 (+1.8v_(Output))
/CM4/+CM4_5V: U9.77 (+5v_(Input)), U9.79 (+5v_(Input)), U9.81 (+5v_(Input)), U9.83 (+5v_(Input)), U9.85 (+5v_(Input)), U9.87 (+5v_(Input)); also elsewhere on the board
/CM4/AIN0: U9.96 (AnalogIP1)
/CM4/AIN1: U9.94 (AnalogIP0)
/CM4/BT_nDis: U9.91 (BT_nDisable)
/CM4/CAM0_C_N: J10.7, U9.140 (CAM0_C_N)
/CM4/CAM0_C_P: J10.8, U9.142 (CAM0_C_P)
/CM4/CAM0_D0_N: J10.1, U9.128 (CAM0_D0_N)
/CM4/CAM0_D0_P: J10.2, U9.130 (CAM0_D0_P)
/CM4/CAM0_D1_N: J10.4, U9.134 (CAM0_D1_N)
/CM4/CAM0_D1_P: J10.5, U9.136 (CAM0_D1_P)
/CM4/CAM1_C_N: J11.7, U9.127 (CAM1_C_N)
/CM4/CAM1_C_P: J11.8, U9.129 (CAM1_C_P)
/CM4/CAM1_D0_N: J11.1, U9.115 (CAM1_D0_N)
/CM4/CAM1_D0_P: J11.2, U9.117 (CAM1_D0_P)
/CM4/CAM1_D1_N: J11.4, U9.121 (CAM1_D1_N)
/CM4/CAM1_D1_P: J11.5, U9.123 (CAM1_D1_P)
/CM4/CAM1_D2_N: U9.133 (CAM1_D2_N)
/CM4/CAM1_D2_P: U9.135 (CAM1_D2_P)
/CM4/CAM1_D3_N: U9.139 (CAM1_D3_N)
/CM4/CAM1_D3_P: U9.141 (CAM1_D3_P)
/CM4/CAM_GPIO: R50.1, R53.1, U9.97 (Camera_GPIO)
/CM4/CM4_+3.3v: D12.2 (A), D13.2 (A), R49.1, R52.1, R55.1, R60.1, U8.5 (VCC)
/CM4/CM4_PCF_SCL: R61.1; also elsewhere on the board
/CM4/CM4_PCF_SDA: R62.1; also elsewhere on the board
/CM4/DSI0_C_N: U9.169 (DSI0_C_N)
/CM4/DSI0_C_P: U9.171 (DSI0_C_P)
/CM4/DSI0_D0_N: U9.157 (DSI0_D0_N)
/CM4/DSI0_D0_P: U9.159 (DSI0_D0_P)
/CM4/DSI0_D1_N: U9.163 (DSI0_D1_N)
/CM4/DSI0_D1_P: U9.165 (DSI0_D1_P)
/CM4/DSI1_C_N: U9.187 (DSI1_C_N)
/CM4/DSI1_C_P: U9.189 (DSI1_C_P)
/CM4/DSI1_D0_N: U9.175 (DSI1_D0_N)
/CM4/DSI1_D0_P: U9.177 (DSI1_D0_P)
/CM4/DSI1_D1_N: U9.181 (DSI1_D1_N)
/CM4/DSI1_D1_P: U9.183 (DSI1_D1_P)
/CM4/DSI1_D2_N: U9.193 (DSI1_D2_N)
/CM4/DSI1_D2_P: U9.195 (DSI1_D2_P)
/CM4/DSI1_D3_N: U9.194 (DSI1_D3_N)
/CM4/DSI1_D3_P: U9.196 (DSI1_D3_P)
/CM4/EEPROM_nWP: U9.20 (EEPROM_nWP)
/CM4/ETH_LEDG: U9.17 (Ethernet_nLED2(3.3v))
/CM4/ETH_LEDY: U9.15 (Ethernet_nLED3(3.3v))
/CM4/GLOBAL_EN: U9.99 (Global_EN)
/CM4/GPIO2: R62.2, U9.58 (GPIO2)
/CM4/GPIO3: R61.2, U9.56 (GPIO3)
/CM4/GPIO4: U9.54 (GPIO4)
/CM4/GPIO5: U9.34 (GPIO5)
/CM4/GPIO6: U9.30 (GPIO6)
/CM4/GPIO7: U9.37 (GPIO7)
/CM4/GPIO8: U9.39 (GPIO8)
/CM4/GPIO9: U9.40 (GPIO9)
/CM4/GPIO10: U9.44 (GPIO10)
/CM4/GPIO11: U9.38 (GPIO11)
/CM4/GPIO12: U9.31 (GPIO12)
/CM4/GPIO13: U9.28 (GPIO13)
/CM4/GPIO14: U9.55 (GPIO14); also elsewhere on the board
/CM4/GPIO15: U9.51 (GPIO15); also elsewhere on the board
/CM4/GPIO16: U9.29 (GPIO16)
/CM4/GPIO17: U9.50 (GPIO17)
/CM4/GPIO18: U9.49 (GPIO18)
/CM4/GPIO19: U9.26 (GPIO19)
/CM4/GPIO20: U9.27 (GPIO20)
/CM4/GPIO21: J10.15, J11.15, U9.25 (GPIO21)
/CM4/GPIO22: U9.46 (GPIO22)
/CM4/GPIO23: U9.47 (GPIO23)
/CM4/GPIO24: U9.45 (GPIO24); also elsewhere on the board
/CM4/GPIO25: U9.41 (GPIO25); also elsewhere on the board
/CM4/GPIO26: U9.24 (GPIO26)
/CM4/GPIO27: U9.48 (GPIO27)
/CM4/GPIO_VREF: R55.2, R56.2, R58.1, R59.1, U9.78 (GPIO_VREF(1.8v/3.3v_Input))
/CM4/HDMI0_CEC: U9.151 (HDMI0_CEC)
/CM4/HDMI0_CK_N: U9.190 (HDMI0_CLK_N)
/CM4/HDMI0_CK_P: U9.188 (HDMI0_CLK_P)
/CM4/HDMI0_D0_N: U9.184 (HDMI0_TX0_N)
/CM4/HDMI0_D0_P: U9.182 (HDMI0_TX0_P)
/CM4/HDMI0_D1_N: U9.178 (HDMI0_TX1_N)
/CM4/HDMI0_D1_P: U9.176 (HDMI0_TX1_P)
/CM4/HDMI0_D2_N: U9.172 (HDMI0_TX2_N)
/CM4/HDMI0_D2_P: U9.170 (HDMI0_TX2_P)
/CM4/HDMI0_HOTPLUG: U9.153 (HDMI0_HOTPLUG)
/CM4/HDMI0_SCL: U9.200 (HDMI0_SCL)
/CM4/HDMI0_SDA: U9.199 (HDMI0_SDA)
/CM4/HDMI1_CEC: U9.149 (HDMI1_CEC)
/CM4/HDMI1_CK_N: U9.166 (HDMI1_CLK_N)
/CM4/HDMI1_CK_P: U9.164 (HDMI1_CLK_P)
/CM4/HDMI1_D0_N: U9.160 (HDMI1_TX0_N)
/CM4/HDMI1_D0_P: U9.158 (HDMI1_TX0_P)
/CM4/HDMI1_D1_N: U9.154 (HDMI1_TX1_N)
/CM4/HDMI1_D1_P: U9.152 (HDMI1_TX1_P)
/CM4/HDMI1_D2_N: U9.148 (HDMI1_TX2_N)
/CM4/HDMI1_D2_P: U9.146 (HDMI1_TX2_P)
/CM4/HDMI1_HOTPLUG: U9.143 (HDMI1_HOTPLUG)
/CM4/HDMI1_SCL: U9.147 (HDMI1_SCL)
/CM4/HDMI1_SDA: U9.145 (HDMI1_SDA)
/CM4/ID_SC: J10.11, R58.2, U9.35 (ID_SC)
/CM4/ID_SD: J10.12, R59.2, U9.36 (ID_SD)
/CM4/PCIE_CLK_N: U9.112 (PCIe_CLK_N); also elsewhere on the board
/CM4/PCIE_CLK_P: U9.110 (PCIe_CLK_P); also elsewhere on the board
/CM4/PCIE_CLK_nREQ: R12.2; also elsewhere on the board
/CM4/PCIE_RX_N: U9.118 (PCIe_RX_N); also elsewhere on the board
/CM4/PCIE_RX_P: U9.116 (PCIe_RX_P); also elsewhere on the board
/CM4/PCIE_TX_N: U9.124 (PCIe_TX_N); also elsewhere on the board
/CM4/PCIE_TX_P: U9.122 (PCIe_TX_P); also elsewhere on the board
/CM4/PCIE_nRST: U9.109 (PCIe_nRST); also elsewhere on the board
/CM4/RUN_PG: U9.92 (RUN_PG)
/CM4/Reserved: U9.76 (Reserved)
/CM4/SCL0: J11.11, U9.80 (SCL0)
/CM4/SDA0: J11.12, U9.82 (SDA0)
/CM4/SD_CLK: U9.57 (SD_CLK)
/CM4/SD_CMD: U9.62 (SD_CMD)
/CM4/SD_DAT0: U9.63 (SD_DAT0)
/CM4/SD_DAT1: U9.67 (SD_DAT1)
/CM4/SD_DAT2: U9.69 (SD_DAT2)
/CM4/SD_DAT3: U9.61 (SD_DAT3)
/CM4/SD_PWR_ON: U9.75 (SD_PWR_ON)
/CM4/SYNC_IN: U9.16 (Ethernet_SYNC_IN(1.8v))
/CM4/SYNC_OUT: U9.18 (Ethernet_SYNC_OUT(1.8v))
/CM4/TRD2_N: U9.9 (Ethernet_Pair2_N)
/CM4/TRD2_P: U9.11 (Ethernet_Pair2_P)
/CM4/TRD3_N: U9.5 (Ethernet_Pair3_N)
/CM4/TRD3_P: U9.3 (Ethernet_Pair3_P)
/CM4/TV_OUT: U9.111 (VDAC_COMP)
/CM4/USB2_N: U9.103 (USB2_N); also elsewhere on the board
/CM4/USB2_P: U9.105 (USB2_P); also elsewhere on the board
/CM4/USBOTG_ID: U9.101 (USB_OTG_ID)
/CM4/WL_nDis: U9.89 (WiFi_nDisable)
/CM4/nEXTRST: U9.100 (nEXTRST)
/CM4/nPWR_LED: U8.2, U9.95 (nPI_LED_PWR)
/CM4/nRPIBOOT: U9.93 (nRPIBOOT)
/PCIE /PCIE20_WAKEn_M2: R11.2; also elsewhere on the board
Earth: C42.2, C44.2, J10.3, J10.6, J10.9, J10.13, J11.3, J11.6, J11.9, J11.13, J12.3, J12.7, J15.7, J15.8, J15.9, J15.10, U8.3 (GND), U9.1 (GND), U9.2 (GND), U9.7 (GND), U9.8 (GND), U9.13 (GND), U9.14 (GND), U9.22 (GND), U9.23 (GND), U9.32 (GND), U9.33 (GND), U9.42 (GND), U9.43 (GND), U9.52 (GND), U9.53 (GND), U9.59 (GND), U9.60 (GND), U9.65 (GND), U9.66 (GND), U9.71 (GND), U9.74 (GND), U9.98 (GND), U9.107 (GND), U9.108 (GND), U9.113 (GND), U9.114 (GND), U9.119 (GND), U9.120 (GND), U9.125 (GND), U9.126 (GND), U9.131 (GND), U9.132 (GND), U9.137 (GND), U9.138 (GND), U9.144 (GND), U9.150 (GND), U9.155 (GND), U9.156 (GND), U9.161 (GND), U9.162 (GND), U9.167 (GND), U9.168 (GND), U9.173 (GND), U9.174 (GND), U9.179 (GND), U9.180 (GND), U9.185 (GND), U9.186 (GND), U9.191 (GND), U9.192 (GND), U9.197 (GND), U9.198 (GND); also elsewhere on the board
unnamed: C41.2, C42.1
unnamed: C44.1, R4.1, R42.1
unnamed: D12.1 (K), R57.1
unnamed: D13.1 (K), R65.1
unnamed: J10.10, J10.14, R49.2, R50.2, R51.2
unnamed: J11.10, J11.14, R52.2, R53.2, R54.2
unnamed: R11.1, U9.104 (Reserved)
unnamed: R57.2, U8.4
unnamed: R60.2, U9.84 (+3.3v_(Output)), U9.86 (+3.3v_(Output))
unnamed: C41.1, T1.2 (CT1), T1.7 (CT2)
unnamed: R4.2, T1.10 (CT3)
unnamed: R42.2, T1.15 (CT4)
unnamed: R65.2, U9.21 (PI_nLED_Activity)
unnamed: R12.1, U9.102 (PCIe_CLK_nREQ)
RX0_N: J15.6, T1.9 (RX-)
RX0_P: J15.3, T1.11 (RX+)
RX_N: J12.2, T1.8 (RD-), U9.12 (Ethernet_Pair0_P)
RX_P: J12.4, T1.6 (RD+), U9.10 (Ethernet_Pair0_N)
TRD0_N: J15.2, T1.14 (TX-)
TRD0_P: J15.1, T1.16 (TX+)
TX_N: J12.6, T1.3 (TD-), U9.6 (Ethernet_Pair1_N)
TX_P: J12.8, T1.1 (TD+), U9.4 (Ethernet_Pair1_P)
VRAW: J15.4, J15.5; also elsewhere on the board

Notes on the sheet:
NETWORK
Activity LED
PWR LED
KAMERA 2
GPIO Voltage select
KAMERA 1

Parts:
C3, C4, C34: 100nF; C_0402_1005Metric
C35, C36, C37, C38, C39, C40: 100nF; C_0603_1608Metric
J5: APCI0079-P002A J8900 M.2 M Key; 121992306; MPN NGFF 67P连接器 M.2 SSD插槽 4+5 H3.2
J6: M3x*0.5 L=3; Screw Terminal Shinbo; MPN SMTSO-M3-3ET
R3: 10K; R_0402_1005Metric
R40: 0R; R_0603_1608Metric
R41: 1K; R_0402_1005Metric

Connections:
/CM4/PCIE_CLK_N: J5.53; also elsewhere on the board
/CM4/PCIE_CLK_P: J5.55; also elsewhere on the board
/CM4/PCIE_CLK_nREQ: J5.52; also elsewhere on the board
/CM4/PCIE_RX_N: J5.41; also elsewhere on the board
/CM4/PCIE_RX_P: J5.43; also elsewhere on the board
/CM4/PCIE_TX_N: C3.1; also elsewhere on the board
/CM4/PCIE_TX_P: C4.1; also elsewhere on the board
/CM4/PCIE_nRST: R41.1; also elsewhere on the board
/PCIE /3.3V_PCIE: C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, J5.2, J5.4, J5.12, J5.14, J5.16, J5.18, J5.70, J5.72, J5.74, R3.1, R40.2
/PCIE /+3.3V_PCIE: R40.1; also elsewhere on the board
/PCIE /PCIE20_TX_N: C3.2, J5.47
/PCIE /PCIE20_TX_P: C4.2, J5.49
/PCIE /PCIE20_WAKEn_M2: J5.54; also elsewhere on the board
/PCIE /PMIC_32KOUT_SOC: J5.68
Earth: C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, J5.1, J5.3, J5.9, J5.15, J5.21, J5.27, J5.33, J5.39, J5.45, J5.51, J5.57, J5.71, J5.73, J5.75, J5.MP1, J5.MP2, J6.1; also elsewhere on the board
unnamed: J5.38, R3.2
unnamed: C34.1, J5.50, R41.2

Notes on the sheet:
PCIE_CLCK_N
PCIE_CLCK_P
PCIE_RX_P
PCIE_CLK_NREQ
PCIE_TX_P
PCIE_NRST
PCIE_RX_N
PCIE_TX_N
3.3V_Input
0R direnç ile sürülüyor isterse devre dışı bırakılabilir

Parts:
D11: LED_WHITE; LED_0603_1608Metric; MPN 0603 翠绿色 LED
J7, J8: M3x*0.5 L=8; Screw Terminal Shinbo; MPN SMTSO-M3-8ET
J9: PinHeader_2x05_P2.00mm_Vertical_MALE; PinHeader_2x05_P2.00mm_Vertical; MPN PinHeader_2x05_P2.00mm_Vertical_MALE
Q1: DTC043ZEBTL; SOT-416; MPN DTC043ZEBTL
R46: 10K; R_0603_1608Metric
R47, R48: DNP; R_0603_1608Metric

Connections:
/CM4/GPIO14: R47.2; also elsewhere on the board
/CM4/GPIO15: R48.2; also elsewhere on the board
/GSM/GSM_STATUS: J9.4, Q1.1 (B)
/GSM/USB_GSM_D+: J9.6; also elsewhere on the board
/GSM/USB_GSM_D-: J9.8; also elsewhere on the board
/RP2040/GPIO21: J9.5; also elsewhere on the board
Earth: J7.1, J8.1, J9.1, J9.2, Q1.2 (E); also elsewhere on the board
unnamed: D11.2 (A), R46.1
unnamed: D11.1 (K), Q1.3 (C)
unnamed: J9.9, R47.1
unnamed: J9.10, R48.1
VIN: J9.3, J9.7, R46.2; also elsewhere on the board

Notes on the sheet:
GSM VİDA DELİKLERİ
GSM LED

Board: 6 copper layers, 126.6 x 50.0 mm, 182 parts (113 on the bottom side), 156 nets.
